ORG 100H
 START:
        MOV DPTR,#TAB1
        MOV R4,#7
       AJMP LOOP
KEY:
    MOV P2,#3H
    JB P2.0,FZ1
   CJNE R4,#7,LOOPZ
   MOV R4,#0FFH
LOOPZ:
    INC R4
    AJMP LOOP
FZ1:
    JB P2.1,KEY
    CJNE R4,#0H,LOOPF
   MOV R4,#08H
LOOPF:
    DEC R4
LOOP:
    MOV A,R4
    MOVC A,@A+DPTR
   MOV P1,A
   ACALL DELAY
   AJMP KEY
DELAY:
    MOV R6,#5
DD1:MOV R5,#80H
DD2:MOV R7,#0
DD:DJNZ R7,DD
   DJNZ R5,DD2
  DJNZ R6,DD1
  RET
TAB1:
	DB 02H,06H,04H,0CH,08H,09H,01H,03H
END 